# Keil uVision project KFZhiJu.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KFZhiJu
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\FWlib\inc;..\User;..\Libraries\CMSIS;..\User\DacaiTFT;..\User\DataFlash;..\User\htusat;..\User\Delay;..\User\Motor;..\User\LoadCode
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c Timer.c StepProcess.c Button.c Ampere.c idwg.c
    ../User/DacaiTFT/: DCTFT.c
    ../User/DataFlash/: DataFlash.c
    ../User/htusat/: htusart.c
    ../User/Delay/: Delay.c
    ../User/Motor/: Motor.c
    ../User/LoadCode/: LoadCode.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_iwdg.c
